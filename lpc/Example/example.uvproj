# Keil uVision project example.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC4337 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: example
  c flags: Optim=1
  c define: CORE_M4
  c include: .\User;.\Drivers\source;.\Drivers\include;.\Core\CMSIS\Include;.\Core\Device\NXP\LPC43xx\Source;.\Core\Device\NXP\LPC43xx\Include
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_LPC43xx.s
  group CMSIS
    ./Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group StdPeriph
    ./Drivers/source/: lpc43xx_adc.c lpc43xx_atimer.c lpc43xx_can.c lpc43xx_cgu.c lpc43xx_dac.c lpc43xx_emc.c lpc43xx_evrt.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_lcd.c lpc43xx_mcpwm.c lpc43xx_nvic.c lpc43xx_pwr.c lpc43xx_qei.c lpc43xx_rgu.c lpc43xx_rit.c lpc43xx_rtc.c lpc43xx_sct.c lpc43xx_scu.c lpc43xx_sdif.c lpc43xx_sdmmc.c lpc43xx_ssp.c lpc43xx_timer.c lpc43xx_uart.c lpc43xx_wwdt.c
  group User
    ./User/: main.c
